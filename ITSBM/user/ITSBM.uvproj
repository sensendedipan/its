# Keil uVision project ITSBM.uvproj, settings and files
target ITSBM (ARM-ADS)
  device: STM32F103RB STMicroelectronics
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x801FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: ITBSM +hex
  c flags: Optim=1
  c define: USE_STDPERIPH_DRIVER, STM32F10X_MD
  c include: ..\cmsis;..\user;..\lib\src;..\lib\inc;..\drivers
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group user
    ./: main.c stm32f10x_it.c flash.c crc16.c messages.c
  group lib
    ../lib/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group cmsis
    ../cmsis/: core_cm3.c system_stm32f10x.c
  group startcode
    ../cmsis/startup/: startup_stm32f10x_md.s
  group drivers
    ../drivers/: led_driver.c i2c_driver.c addr_driver.c spi_driver.c usart1_driver.c usart2_driver.c radio_driver.c adc_driver.c timer_driver.c fifo.c at24cx_driver.c w25qx_driver.c board.c wdg_driver.c delay_driver.c
